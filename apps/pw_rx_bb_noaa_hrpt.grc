<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>pw_rx_bb_noaa_hrpt</value></param>
<param><key>title</key><value>Enhanced NOAA HRPT Receiver</value></param>
<param><key>author</key><value>POES Weather Ab Ltd &amp; Martin Blaho</value></param>
<param><key>description</key><value>Enhanced NOAA HRPT Receiver</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, os</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>600*1109</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>samp_rate/sym_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hs</value></param>
<param><key>value</key><value>int(sps/2.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_carrier_offset</value></param>
<param><key>value</key><value>2*math.pi*100e3/samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_clock_offset</value></param>
<param><key>value</key><value>0.1</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>displays</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['RX NOAA HRPT', 'Information']</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>sample_rate_text</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>value</key><value>samp_rate</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3,0,1,1</value></param>
<param><key>notebook</key><value>displays,1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>satellite_text</value></param>
<param><key>label</key><value>Satellite</value></param>
<param><key>value</key><value>satellite</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,1,1,1</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>freq_tb</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,1,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>pll_alpha</value></param>
<param><key>label</key><value>PLL Alpha</value></param>
<param><key>value</key><value>saved_pll_alpha</value></param>
<param><key>min</key><value>0.005</value></param>
<param><key>max</key><value>0.5</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,1,1,1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>satellite</value></param>
<param><key>label</key><value>Satellite</value></param>
<param><key>value</key><value>'NOAA-XX'</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>S</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>value</key><value>35</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>g</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>side_text</value></param>
<param><key>label</key><value>USRP Side</value></param>
<param><key>value</key><value>side</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>datetime_text</value></param>
<param><key>label</key><value>Acquisition start</value></param>
<param><key>value</key><value>strftime("%A, %B %d %Y %H:%M:%S", localtime())</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
<param><key>notebook</key><value>displays, 1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>clock_alpha</value></param>
<param><key>label</key><value>Clock alpha</value></param>
<param><key>value</key><value>saved_clock_alpha</value></param>
<param><key>min</key><value>0.001</value></param>
<param><key>max</key><value>0.1</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,2,1,1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>1698e6</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain_slider</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>value</key><value>gain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>grid_pos</key><value>2,0,1,1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>config_filename</value></param>
<param><key>value</key><value>os.environ['HOME']+'/.gnuradio/noaa_hrpt.conf'</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>frames_outfile_text</value></param>
<param><key>label</key><value>Frames filename</value></param>
<param><key>value</key><value>frames_file</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>4,0,1,1</value></param>
<param><key>notebook</key><value>displays,1</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>from time import strftime, localtime</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_check</value></param>
<param><key>label</key><value>Sync check</value></param>
<param><key>value</key><value>False</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>c</value></param>
</block>
<block>
<key>noaa_hrpt_decoder</key>
<param><key>id</key><value>noaa_hrpt_decoder_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>verbose</key><value>True</value></param>
<param><key>output</key><value>False</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>NOAA Decimation: Decimation must be either 16, 24 or 32</value></param>
</block>
<block>
<key>analog_agc_xx</key>
<param><key>id</key><value>analog_agc_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>1e-5</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0/32768.0</value></param>
<param><key>max_gain</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>side</value></param>
<param><key>label</key><value>Side</value></param>
<param><key>value</key><value>A:0</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>R</value></param>
</block>
<block>
<key>noaa_hrpt_pll_cf</key>
<param><key>id</key><value>pll</value></param>
<param><key>alpha</key><value>pll_alpha</value></param>
<param><key>beta</key><value>pll_alpha**2/4.0</value></param>
<param><key>max_offset</key><value>max_carrier_offset</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>baseband</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>baseband</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>frames</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>frames_file</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>rate</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>rate_tb</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>value</key><value>rate</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1,0,1,1</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>length</key><value>hs</value></param>
<param><key>scale</key><value>1.0/hs</value></param>
<param><key>max_iter</key><value>4000</value></param>
</block>
<block>
<key>digital_clock_recovery_mm_xx</key>
<param><key>id</key><value>digital_clock_recovery_mm_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>omega</key><value>sps/2.0</value></param>
<param><key>gain_omega</key><value>clock_alpha**2/4.0</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>gain_mu</key><value>clock_alpha</value></param>
<param><key>omega_relative_limit</key><value>max_clock_offset</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>value</key><value>2e6</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>r</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>sync_check_txt</value></param>
<param><key>label</key><value>Continuous sync check</value></param>
<param><key>value</key><value>sync_check</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,2,1,1</value></param>
</block>
<block>
<key>digital_binary_slicer_fb</key>
<param><key>id</key><value>digital_binary_slicer_fb_0</value></param>
</block>
<block>
<key>poesweather_noaa_hrpt_deframer</key>
<param><key>id</key><value>poesweather_noaa_hrpt_deframer_0</value></param>
<param><key>sync_check</key><value>False</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>frames</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frames_file</value></param>
<param><key>label</key><value>Frames output filename</value></param>
<param><key>value</key><value>os.environ['HOME'] + '/data/noaa/frames/NOAA-XX.hrpt'</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>o</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>baseband_file</value></param>
<param><key>label</key><value>Baseband output filename</value></param>
<param><key>value</key><value>os.environ['HOME'] + '/data/noaa/baseband/NOAA-XX.dat'</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>F</value></param>
</block>
<block>
<key>blocks_complex_to_interleaved_short</key>
<param><key>id</key><value>blocks_complex_to_interleaved_short_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_1</value></param>
<param><key>file</key><value>baseband_file</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>side</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>gain_slider</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>NOAA HRPT FFT Spectrum</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>5</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>-70</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.4</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>displays, 0</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_clock_alpha</value></param>
<param><key>value</key><value>0.001</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>satellite</value></param>
<param><key>option</key><value>'clock_alpha'</value></param>
<param><key>writeback</key><value>clock_alpha</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_pll_alpha</value></param>
<param><key>value</key><value>0.005</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>satellite</value></param>
<param><key>option</key><value>'pll_alpha'</value></param>
<param><key>writeback</key><value>pll_alpha</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>saved_gain</value></param>
<param><key>value</key><value>gain</value></param>
<param><key>type</key><value>real</value></param>
<param><key>config_file</key><value>config_filename</value></param>
<param><key>section</key><value>satellite</value></param>
<param><key>option</key><value>'gain'</value></param>
<param><key>writeback</key><value>gain_slider</value></param>
</block>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>noaa_hrpt_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc_xx_0</source_block_id><sink_block_id>pll</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pll</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>analog_agc_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>digital_clock_recovery_mm_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_clock_recovery_mm_xx_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>digital_binary_slicer_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_binary_slicer_fb_0</source_block_id><sink_block_id>poesweather_noaa_hrpt_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>poesweather_noaa_hrpt_deframer_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_complex_to_interleaved_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_interleaved_short_0</source_block_id><sink_block_id>blocks_file_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
